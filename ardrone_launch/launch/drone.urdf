Commit message: new things

File: ardrone_launch/launch/drone.urdf (robot description, URDF)
Before this commit: robot drone, 5 links, 4 joints
Links:
- link base_link: mass 0.3 -> None
